# Keil uVision project Fire_uCOS.uvprojx, settings and files
target nFLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_uCOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,PROGRAM_ADDR = 0x08000000,__CC_ARM,USE_FULL_LL_DRIVER,ARM_MATH_CM7
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M4\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\RealView;..\..\User\BSP\ABC;..\..\Libraries\STM32H7xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x4000000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../../Libraries/CMSIS/: arm_cortexM7lfsp_math.lib
  group STM32H7xx_HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group USER_APP
    ../../User/: stm32h7xx_it.c main.c
    ../../User/APP/: os_app_hooks.c app.c
    ../../User/APP/MY_APP/: APP_LCD.c
  group BSP
    ../../User/BSP/: bsp.c cpu_bsp.c
    ../../User/BSP/usart/: bsp_usart.c
    ../../User/BSP/fonts/: font8.c font12.c font16.c font20.c font24.c
    ../../User/BSP/lcd/: bsp_lcd.c
    ../../User/BSP/mpu/: bsp_mpu.c
    ../../User/BSP/sdram/: bsp_sdram.c
    ../../User/BSP/JDY40/: JDY40.c
    ../../User/BSP/INMP441/: INMP441.c
    ../../User/BSP/touch/: bsp_i2c_touch.c bsp_touch_gtxx.c button.c graph.c
    ../../User/BSP/dfsdm/: dfsdm.c
  group μC/CPU
    ../../User/uC-CPU/Cache/ARM/armv7m_generic_l1/: cpu_cache_armv7m_generic_l1.c
    ../../User/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../User/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group μC/LIB
    ../../User/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../User/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group μC/OS-III Source
    ../../User/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group μC/OS-III Port
    ../../User/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group AL
    ../../User/BSP/al/: AL_Array.c
  group SD
    ../../User/BSP/FATFS/option/: cc936.c
    ../../User/BSP/FATFS/: diskio.c ff.c ff_gen_drv.c
    ../../User/BSP/sd_card/: bsp_sdio_sd.c
    ../../User/BSP/FATFS/drivers/: fatfs_sd_sdio.c
  group STemWin/conf
    ../../emWin/Config/: GUIConf.c LCDConf_Lin_Template.c
  group STemWin/demo
    ../../emWin/emWinDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c
  group STemWin/lib
    ../../emWin/Lib/: STemWin_CM7_OS_wc16.a
  group STemWin/os
    ../../emWin/OS/: GUI_X_uCOS.c
target outFLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: as above
  output: Fire_uCOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,PROGRAM_ADDR = 0x90000000,__CC_ARM,USE_FULL_LL_DRIVER,ARM_MATH_CM7
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M4\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\RealView;..\..\User\BSP\ABC;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\emWin\inc;..\..\emWin\Config;..\..\emWin\emWinDemo
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x4000000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
target nSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: as above
  output: Fire_uCOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,__CC_ARM,USE_FULL_LL_DRIVER,ARM_MATH_CM7,VECT_TAB_SRAM
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x4000000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\nSRAM.sct
